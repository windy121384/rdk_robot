# Keil uVision project RosRobotControllerM4.uvprojx, settings and files
target RosRobotControllerM4 (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RosRobotControllerM4 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_HOST/Target;../USB_HOST/App;../Third_Party/Fusion/Fusion;../Third_Party/LVGL/porting;../Third_Party/LVGL/src;../Third_Party/LVGL;../Third_Party/U8g2;../Third_Party/RTT;../Third_Party/Lw;../Third_Party;../Hiwonder/LVGL_UI/guider_customer_fonts;../Hiwonder/LVGL_UI/guider_fonts;../Hiwonder/LVGL_UI/images;../Hiwonder/LVGL_UI;../Hiwonder/USB_HOST;../Hiwonder/Peripherals;../Hiwonder/Portings;../Hiwonder/Chassis;../Hiwonder/System;../Hiwonder/Misc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c motor_test.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Third_Party/RTT
    ../Third_Party/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Third_Party/Fusion
    ../Third_Party/Fusion/Fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group Third_Party/LW
    ../Third_Party/Lw/: lwmem.c lwmem_sys_cmsis_os.c lwpkt.c lwrb.c lwshell.c
  group Third_party/U8g2
    ../Third_Party/U8g2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_stdio.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Third_Party/LVGL/src
    ../Third_Party/LVGL/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Third_Party/LVGL/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Third_Party/LVGL/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Third_Party/LVGL/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Third_Party/LVGL/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Third_Party/LVGL/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Third_Party/LVGL/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group Third_Party/LVGL/porting
    ../Third_Party/LVGL/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ../Third_Party/LVGL/: lv_conf.h
  group Hiwonder/USB_HOST
    ../Hiwonder/USB_HOST/: usbh_hid_gamepad.c usbh_hid_gamepad.h usbh_hiwonder_hid.c usbh_hiwonder_hid.h
  group Hiwonder/LVGL_UI
    ../Hiwonder/LVGL_UI/: events_init.c gui_guider.c setup_scr_screen_empty.c setup_scr_screen_imu.c setup_scr_screen_ps2.c setup_scr_screen_sbus.c setup_scr_screen_startup.c setup_scr_screen_sys.c custom.c
    ../Hiwonder/LVGL_UI/images/: _logo18_148x18.c
    ../Hiwonder/LVGL_UI/guider_fonts/: lv_font_SourceHanSansSC_Normal_16.c lv_font_ps2_icons_14.c lv_font_SourceHanSansSC_Normal_12.c lv_font_SourceHanSansSC_Light_12.c lv_font_SourceHanSansSC_Normal_14.c
  group Hiwonder/Peripherals
    ../Hiwonder/Peripherals/: button.c buzzer.c led.c display_st7735.c imu_mpu6050.c pwm_servo.c serial_servo.c encoder_motor.c QMI8658.c QMI8658.h QMI8658reg.h
  group Hiwonder/Misc
    ../Hiwonder/Misc/: checksum.c log.h log.c packet.c pid.c sbus.c syscall.c object.h
  group Hiwonder/Chassis
    ../Hiwonder/Chassis/: chassis.h differential_chassis.c differential_chassis.h mecanum_chassis.c mecanum_chassis.h ackermann_chassis.c ackermann_chassis.h
  group Hiwonder/Porting
    ../Hiwonder/Portings/: led_porting.c button_porting.c buzzer_porting.c imu_porting.c lcd_porting.c motors_param.h motor_porting.c packet_porting.c pwm_servo_porting.c sbus_porting.c bluetooth_porting.c lwmem_porting.c chassis_porting.c u8g2_porting.c serial_servo_porting.c
  group Hiwonder/System
    ../Hiwonder/System/: global_conf.h global.h battery_handle.c gampad_handle.c gui_handle.c app.c packet_handle.c packet_handle.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
